# IAR project wac.ewp, settings and files
configuration Lib_WAC_CM4F (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: MICO_PREBUILT_LIBS
  ICCARM.CCDiagSuppress: Pa050,Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\MiCO\security\Sodium\inc; ..\..\..\..\..\..\MiCO\security\SRP_6a\inc; ..\..\..\..\..\..\platform; ..\..\..\..\..\..\platform\Cortex-M4F; ..\..\..\..\..\..\MiCO\system; ..\..\..\..\..\..\libraries\utilities\json_c; ..\..\..\..\..\..\libraries\utilities\; ..\..\..\..\..\..\libraries\drivers\; ..\..\..; ..\..\..\..\..\..\board\MK3165; ..\..\..\..\..\..\MiCO\security; ..\..\..\..\..\..\libraries\drivers\MiCOKit_EXT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\board\MK3165
  OBJCOPY.OOCOutputFile: HomeKit.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3165\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Lib_WAC_CM3 (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\include; ..\..\..\..\..\..\MiCO\security\Sodium\inc; ..\..\..\..\..\..\MiCO\security\SRP_6a\inc; ..\..\..\..\..\..\platform; ..\..\..\..\..\..\platform\Cortex-M3; ..\..\..\..\..\..\MiCO\system; ..\..\..\..\..\..\libraries\utilities\json_c; ..\..\..\..\..\..\libraries\utilities\; ..\..\..\..\..\..\libraries\drivers\; ..\..\..; ..\..\..\..\..\..\board\MK3165; ..\..\..\..\..\..\MiCO\security; ..\..\..\..\..\..\libraries\drivers\MiCOKit_EXT
  group wac_src
    ../../src/: MFi-SAP.c MFiSAPServer.c WAC.c
