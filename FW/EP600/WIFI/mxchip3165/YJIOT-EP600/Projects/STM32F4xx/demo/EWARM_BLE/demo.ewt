<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3238</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MiCOKit-3239</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>BTE_low_energy</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>BTE_dual_mode</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\bluetooth\ble_hello_sensor\ble_hello_sensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\bluetooth\ble_hello_sensor\ble_hello_sensor.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\demos\bluetooth\ble_hello_sensor\mico_config.h</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-3165</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3165\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3165\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3165\platform_config.h</name>
      </file>
    </group>
    <group>
      <name>MiCOKit-3166</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3166\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3166\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3166\platform_config.h</name>
      </file>
    </group>
    <group>
      <name>MiCOKit-3238</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3238\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3238\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3238\platform_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3238\wifi_nvram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3238\wifi_nvram_image.h</name>
      </file>
    </group>
    <group>
      <name>MiCOKit-3239</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3239\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3239\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3239\platform_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3239\wifi_nvram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3239\wifi_nvram_image.h</name>
      </file>
    </group>
    <group>
      <name>MiCOKit-3240</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3240\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3240\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3240\platform_config.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3240\wifi_nvram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3240\wifi_nvram_image.h</name>
      </file>
    </group>
    <group>
      <name>MiCOKit-3288</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3288\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3288\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\MK3288\platform_config.h</name>
      </file>
    </group>
    <group>
      <name>NUCLEO_F411RE</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\NUCLEO_F411RE\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\NUCLEO_F411RE\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\board\NUCLEO_F411RE\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MiCODrivers\MiCODriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_platform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_rtos.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_security.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_socket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_system.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\mico_wlan.h</name>
    </file>
  </group>
  <group>
    <name>libraries</name>
    <group>
      <name>bluetooth</name>
      <group>
        <name>BTE</name>
        <group>
          <name>Components</name>
          <group>
            <name>gki</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\gki\common\gki_buffer.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\gki\common\gki_debug.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\gki\mico\gki_mico.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\gki\common\gki_time.c</name>
            </file>
          </group>
          <group>
            <name>hcis</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\hcis\hcill_proto.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\hcis\hcilp.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\hcis\hcisu_h4.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\hcis\hciutil.c</name>
            </file>
          </group>
          <group>
            <name>stack</name>
            <group>
              <name>brcm</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\brcm\brcm_ble.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\brcm\brcm_prm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\brcm\brcm_tbfc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\brcm\bte_brcm.c</name>
              </file>
            </group>
            <group>
              <name>btm</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_acl.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble_addr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble_bgconn.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble_gap.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_ble_privacy.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_cfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_dev.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_devctl.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_inq.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_pm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_sco.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_sec.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btm\btm_sec_nvram.c</name>
              </file>
            </group>
            <group>
              <name>btu</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btu\btu_hcif.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btu\btu_init.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\btu\btu_task.c</name>
              </file>
            </group>
            <group>
              <name>gap</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gap\gap_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gap\gap_ble.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gap\gap_conn.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gap\gap_utils.c</name>
              </file>
            </group>
            <group>
              <name>gatt</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\att_protocol.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_attr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_auth.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_cl.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_sr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\gatt_utils.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\gatt\legattdb\legattdb.c</name>
              </file>
            </group>
            <group>
              <name>hcic</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\hcic\hciblecmds.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\hcic\hcicmds.c</name>
              </file>
            </group>
            <group>
              <name>l2cap</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_ble.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_ble_conn.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_ble_utils.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_csm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_fcr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_link.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\l2cap\l2c_utils.c</name>
              </file>
            </group>
            <group>
              <name>rfcomm</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\port_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\port_rfc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\port_utils.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_l2cap_if.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_mx_fsm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_port_fsm.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_port_if.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_ts_frames.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\rfcomm\rfc_utils.c</name>
              </file>
            </group>
            <group>
              <name>sdp</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_db.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_discovery.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_server.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\sdp\sdp_utils.c</name>
              </file>
            </group>
            <group>
              <name>smp</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\p_256_curvepara.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\p_256_ecc_pp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\p_256_multprecision.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_act.c</name>
                <configuration>
                  <name>MiCOKit-3238</name>
                </configuration>
                <configuration>
                  <name>MiCOKit-3239</name>
                </configuration>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_api.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_br_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_cmac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_keys.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_l2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_main.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\smp\smp_utils.c</name>
              </file>
            </group>
            <group>
              <name>wbt</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\stack\wbt\wbt_ext.c</name>
              </file>
            </group>
          </group>
          <group>
            <name>udrv</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\udrv\mico\userial_mico.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>gki</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\gki\common\gki.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Components\gki\common\gki_common.h</name>
          </file>
        </group>
        <group>
          <name>mico_bt_api</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_ble_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_dev_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_gatt.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_gatt_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_hidd_ble_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_int.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_l2c_le_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_l2c_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_main.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_rfcomm_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_sco_wrapper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_sdp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_api\mico_bt_sdp_wrapper.c</name>
          </file>
        </group>
        <group>
          <name>Projects</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Projects\bte\main\bte_hcisu.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Projects\bte\main\bte_init.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Projects\bte\main\bte_load.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Projects\bte\main\bte_version.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\Projects\bte\embedded\mico\lib\mico_post_reset.c</name>
          </file>
        </group>
        <group>
          <name>proto_disp</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\proto_disp\hcidisp.c</name>
          </file>
        </group>
        <configuration>
          <name>MiCOKit-3238</name>
        </configuration>
        <configuration>
          <name>MiCOKit-3239</name>
        </configuration>
      </group>
      <group>
        <name>firmware</name>
        <group>
          <name>43438A1</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\firmware\43438A1\26MHz\bt_firmware_image.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>mico_bt_platform</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_bt_bus.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_bt_hcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_bt_logmsg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_bt_nvram_access.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\BTE\mico_bt_platform\mico_upio.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\dual_mode\BTE_dual_mode.Cortex-M4.IAR.release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\bluetooth\low_energy\BTE_low_energy.Cortex-M4.IAR.release.a</name>
      </file>
      <configuration>
        <name>BTE_low_energy</name>
      </configuration>
      <configuration>
        <name>BTE_dual_mode</name>
      </configuration>
    </group>
    <group>
      <name>daemons</name>
      <group>
        <name>bt_smart</name>
        <group>
          <name>include</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\include\mico_bt.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\include\mico_bt_peripheral.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\include\mico_bt_smart_attribute.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\include\mico_bt_smart_interface.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\include\mico_bt_smartbridge.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\include\mico_bt_smartbridge_constants.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\include\mico_bt_smartbridge_gatt.h</name>
          </file>
        </group>
        <group>
          <name>internal</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_peripheral_stack_interface.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_peripheral_stack_interface.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smart_attribute.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_att_cache_manager.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_att_cache_manager.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_helper.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_helper.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_socket_manager.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_socket_manager.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_stack_interface.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\internal\bt_smartbridge_stack_interface.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\mico_bt_management.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\mico_bt_peripheral.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\mico_bt_smartbridge.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\mico_bt_smartbridge_cfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\mico_bt_smartbridge_cfg_size.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\bt_smart\mico_bt_smartbridge_gatt.c</name>
        </file>
      </group>
      <group>
        <name>homekit_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\homekit_server\Lib_HomeKit_Server.Cortex-M4F.IAR.release.a</name>
        </file>
      </group>
      <group>
        <name>http_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http-strings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http-strings.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http_parse.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\http_parse.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_handle.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_priv.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_ssi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_sys.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\daemons\http_server\httpd_wsgi.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>display</name>
        <group>
          <name>VGM128064</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\AsciiLib.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\AsciiLib.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oled.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oled.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\display\VGM128064\oledfont.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>keypad</name>
        <group>
          <name>gpio_button</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\keypad\gpio_button\button.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\keypad\gpio_button\button.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>led</name>
        <group>
          <name>P9813</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\hsb2rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\hsb2rgb_led.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\rgb_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\rgb_led\P9813\rgb_led.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCODriverMFiAuth\MiCODriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-EXT</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\micokit_ext_mfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\motion_sensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\motion_sensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_EXT\temp_hum_sensor.c</name>
        </file>
      </group>
      <group>
        <name>MiCOKit-STmem</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\MiCOKit_STmems\MiCOKit_STmems_def.h</name>
        </file>
      </group>
      <group>
        <name>motor</name>
        <group>
          <name>dc_motor</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\motor\dc_motor\dc_motor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\motor\dc_motor\dc_motor.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>sensor</name>
        <group>
          <name>ADPS9930</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\APDS9930\APDS9930.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\APDS9930\APDS9930.h</name>
          </file>
        </group>
        <group>
          <name>BMA2x2</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMA2x2\bma2x2_user.h</name>
          </file>
        </group>
        <group>
          <name>BME280</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BME280\bme280_user.h</name>
          </file>
        </group>
        <group>
          <name>BMG160</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMG160\bmg160_user.h</name>
          </file>
        </group>
        <group>
          <name>BMM050</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050_user.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\BMM050\bmm050_user.h</name>
          </file>
        </group>
        <group>
          <name>DHT11</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\DHT11\DHT11.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\DHT11\DHT11.h</name>
          </file>
        </group>
        <group>
          <name>HTS221</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\HTS221\hts221.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\HTS221\hts221.h</name>
          </file>
        </group>
        <group>
          <name>infrared_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\infrared_adc\infrared_reflective.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\infrared_adc\infrared_reflective.h</name>
          </file>
        </group>
        <group>
          <name>light_adc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\light_adc\light_sensor.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\light_adc\light_sensor.h</name>
          </file>
        </group>
        <group>
          <name>LPS25HB</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LPS25HB\lps25hb.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LPS25HB\lps25hb.h</name>
          </file>
        </group>
        <group>
          <name>LSM9DS1</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1_acc_gyr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\LSM9DS1\lsm9ds1_mag.c</name>
          </file>
        </group>
        <group>
          <name>UVIS25</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\UVIS25\uvis25.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\sensor\UVIS25\uvis25.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>protocols</name>
    </group>
    <group>
      <name>utilities</name>
      <group>
        <name>json_c</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\bits.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\debug.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_inttypes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object_private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\AESUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\HTTPUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\LinkListUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SecurityUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SHAUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SocketUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TimeUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>mico</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\MiCO.1062.SDIO.Cortex-M4.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\MiCO.1062.SPI.Cortex-M4.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\MiCO.3166.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\MiCO.3238.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\MiCO.3239.IAR.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\mico_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\mxchipWNet_cm4f_8801.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\core\rf_driver\wlan_firmware.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>LwIP</name>
        <group>
          <name>mico</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\net\LwIP\mico\mico_socket.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>RTOS</name>
      <group>
        <name>FreeRTOS</name>
        <group>
          <name>mico</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\mico\mico_rtos.c</name>
          </file>
        </group>
        <group>
          <name>ver9.0.0</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\croutine.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\event_groups.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\MemMang\heap_3.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\list.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F\port.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F\portasm.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\queue.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\tasks.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\timers.c</name>
          </file>
        </group>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\RTOS\mico_rtos_common.c</name>
      </file>
    </group>
    <group>
      <name>security</name>
      <group>
        <name>curve25519</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\Curve25519\curve25519-donna.c</name>
        </file>
      </group>
      <group>
        <name>SHA</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\hkdf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\hmac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha224-256.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\sha384-512.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SHAUtils\usha.c</name>
        </file>
      </group>
      <group>
        <name>TLS</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\security\TLS\wolfSSL\Lib_wolfSSL.Cortex-M4F.IAR.release.a</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\security\Sodium\Lib_Sodium.IAR.release.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\security\SRP_6a\Lib_SRP6a.IAR.release.a</name>
      </file>
    </group>
    <group>
      <name>system</name>
      <group>
        <name>easylink</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\airkiss_discovery\airkiss_discovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\MFi_WAC\Lib_MFi_WAC.Cortex-M4F.IAR.release.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\airkiss_discovery\lib_airkiss\libairkiss.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink_delegate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\easylink\system_easylink_wac.c</name>
        </file>
      </group>
      <group>
        <name>mdns</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\mico_mdns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\mico_mdns.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mdns\system_discovery.c</name>
        </file>
      </group>
      <group>
        <name>qc_test</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\qc_test.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_ble.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_cli.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MiCO\system\qc_test\internal\qc_test_tcpip.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\config_server\config_server.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\config_server\config_server_menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\command_console\mico_cli.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\command_console\mico_cli.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_notification.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_para_storage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\mico_system_power_daemon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\system.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\system_misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp_ota.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftp_ota.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MiCO\system\tftp_ota\tftpc.o</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M4</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M4\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M4\hardfault.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\Cortex-M4\platform_core.c</name>
      </file>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx</name>
      <group>
        <name>EWARM</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\EWARM\startup_stm32f411xe_IAR.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\EWARM\startup_stm32f412xg_IAR.s</name>
        </file>
      </group>
      <group>
        <name>Peripherals</name>
        <group>
          <name>Libraries</name>
          <group>
            <name>STM32F4xx_StdPeriph_Driver</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash_ramfunc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_qspi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\libraries\system_stm32f4xx.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_mcu_powersave.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_pwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_rng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\peripherals\platform_watchdog.c</name>
        </file>
      </group>
      <group>
        <name>Wi-Fi_Bus_Driver</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\wlan_bus_driver\wlan_bus_SDIO.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\wlan_bus_driver\wlan_bus_SPI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\wlan_bus_driver\wlan_platform.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\platform\MCU\STM32F4xx\platform_init.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\mico_platform_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\platform_nsclock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\platform\MCU\wlan_platform_common.c</name>
    </file>
  </group>
</project>


