# Keil uVision project OB39A08T1.uvproj, settings and files
target OB39A08T1 (MCS-51)
  device: OB39A08T1 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0x01) CLOCK(25000000) MDU_R515
  output: OB39A08T1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\User\led;..\User\touch;..\User\timer;..\User\inc
  group Source Group 1
    ./: STARTUP.A51
    ../User/: InitROM.asm
  group User
    ../User/: Main.c OB39A08T1.h data.c
  group LED
    ../User/led/: led.c
  group TOUCH
    ../User/touch/: touch.c
  group TIMER
    ../User/timer/: timer.c
