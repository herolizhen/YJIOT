# IAR project Backup (2) of EP600_S.ewp, settings and files
configuration MiCOKit-3165 (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000; STM32F411xE; MXCHIP; FreeRTOS_VERSION="7.1.0"; LwIP_VERSION_MAJOR=1; LwIP_VERSION_MINOR=4; WOLFSSL_IAR_ARM; FreeRTOS_VERSION_MAJOR=9
  ICCARM.CCDiagSuppress: Pa050,Pe301
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\board\MK3165; ..\..\..\..\platform\include; ..\..\..\..\platform\Cortex-M4; ..\..\..\..\platform\Cortex-M4\CMSIS; ..\..\..\..\platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\drivers\spi_flash; ..\..\..\..\libraries\drivers; ..\..\..\..\librariesdaemons\bt_smart\include; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\MiCO\security; ..\..\..\..\MiCO\security\Curve25519; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS; ..\..\..\..\mico\system; ..\..\..\..\MiCO\system\qc_test; ..\..\..\..\MiCO\system\qc_test\internal; ..\..\..\..\platform\MCU\STM32F4xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\platform; ..\..\..\..\libraries\utilities\base64; ..\..\..\..\libraries\protocols\fog_v2; ..\..\..\..\libraries\protocols\mqtt; ..\..\..\..\libraries\protocols\mqtt\MQTTPacket; ..\..\..\..\libraries\protocols\mqtt\mico; ..\..\..\..\libraries\protocols\fog_v2\fog_bonjour; ..\..\..\..\libraries\protocols\fog_v2\fog_http; ..\..\..\..\libraries\protocols\fog_v2\fog_mqtt; ..\..\..\..\libraries\protocols\fog_v2\fog_ota; ..\..\..\..\libraries\protocols\fog_v2\fog_tcp_server; ..\..\..\..\demos\EP600_S\User; ..\..\..\..\demos\EP600_S\AppFramework
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\board\MK3165; ..\..\..\..\demos\EP1500\User
  OBJCOPY.OOCOutputFile: EP600_S.bin
  ILINK.IlinkOutputFile: EP600_S.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3165\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3288 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000; STM32F411xE; MXCHIP; FreeRTOS_VERSION="9.0.0"; LwIP_VERSION_MAJOR=1; LwIP_VERSION_MINOR=4; WOLFSSL_IAR_ARM; FreeRTOS_VERSION_MAJOR=9
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\board\MK3288; ..\..\..\..\platform\include; ..\..\..\..\platform\Cortex-M4; ..\..\..\..\platform\Cortex-M4\CMSIS; ..\..\..\..\platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\drivers\spi_flash; ..\..\..\..\libraries\drivers; ..\..\..\..\mico\system; ..\..\..\..\mico\system\qc_test; ..\..\..\..\mico\system\qc_test\internal; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\base64; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS; ..\..\..\..\platform\MCU\STM32F4xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\platform
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\board\MK3288
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.BASIC.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3288\micoLinkerForIAR.icf
configuration NUCLEO_F411RE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers; ..\..\..\..\mico\system; ..\..\..\..\mico\system\qc_test; ..\..\..\..\mico\system\qc_test\internal; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\base64; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\mico\security\TLS\wolfSSL; ..\..\..\..\Board\NUCLEO_F411RE; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS; ..\..\..\..\platform\MCU\STM32F4xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\platform
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\board\NUCLEO_F411RE
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\NUCLEO_F411RE\micoLinkerForIAR.icf
configuration MiCOKit-3238 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=26000000; DEBUG; BUILDCFG; STM32F411xE; MXCHIP; FreeRTOS_VERSION="9.0.0"; LwIP_VERSION_MAJOR=1; LwIP_VERSION_MINOR=4; WOLFSSL_IAR_ARM; FreeRTOS_VERSION_MAJOR=9
  ICCARM.CCDiagSuppress: Pa050, Pe301, Pa039
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MK3238; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\base64; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\mico\system\qc_test\internal; ..\..\..\..\mico\system\qc_test; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\protocols\gagent\inc; ..\..\..\..\libraries\bluetooth\include; ..\..\..\..\libraries\daemons\bt_smart\include; ..\..\..\..\libraries\daemons\bt_smart\internal; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS; ..\..\..\..\platform\MCU\STM32F4xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\platform; ..\..\..\..\libraries\drivers\MiCOKit_EXT
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\board\MK3238
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3238\micoLinkerForIAR.icf
configuration MiCOKit-3166 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F412RG ST STM32F412RG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000; STM32F412xG; MXCHIP; FreeRTOS_VERSION="9.0.0"; LwIP_VERSION_MAJOR=1; LwIP_VERSION_MINOR=4; WOLFSSL_IAR_ARM; FreeRTOS_VERSION_MAJOR=9
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MK3166; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers; ..\..\..\..\mico\system; ..\..\..\..\mico\system\qc_test; ..\..\..\..\mico\system\qc_test\internal; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\base64; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM3; ..\..\..\..\MiCO\RTOS; ..\..\..\..\platform\MCU\STM32F4xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\platform
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM3; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\board\MK3166
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3166\micoLinkerForIAR.icf
configuration MiCOKit-3239 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F412RG ST STM32F412RG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=26000000; DEBUG; BUILDCFG; STM32F412xG; MXCHIP; FreeRTOS_VERSION="9.0.0"; LwIP_VERSION_MAJOR=1; LwIP_VERSION_MINOR=4; WOLFSSL_IAR_ARM; FreeRTOS_VERSION_MAJOR=9
  ICCARM.CCDiagSuppress: Pa050, Pe301, Pa039
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\Board\MK3239; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\base64; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\protocols\gagent\inc; ..\..\..\..\libraries\bluetooth\include; ..\..\..\..\libraries\daemons\bt_smart\include; ..\..\..\..\libraries\daemons\bt_smart\internal; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS; ..\..\..\..\MiCO\system; ..\..\..\..\MiCO\system\qc_test; ..\..\..\..\MiCO\system\qc_test\internal; ..\..\..\..\platform\MCU\STM32F4xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\platform; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\libraries\drivers\MiCOKit_EXT
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver9.0.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\board\MK3239
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3239\micoLinkerForIAR.icf
configuration BTE_low_energy (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=26000000; MICO_BLE; DEBUG; BUILDCFG; MICO_PREBUILT_LIBS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\mble\wlan_config; ..\..\..\..\include; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3238; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\protocols\gagent\inc; ..\..\..\..\libraries\bluetooth\include; ..\..\..\..\libraries\bluetooth\BTE\Projects\bte\main; ..\..\..\..\libraries\bluetooth\BTE\Components\stack\include; ..\..\..\..\libraries\bluetooth\include; ..\..\..\..\libraries\bluetooth; ..\..\..\..\libraries\bluetooth\BTE\mico; ..\..\..\..\platform\include
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3238\micoLinkerForIAR.icf
configuration BTE_dual_mode (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: as above
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: as above
configuration MiCOKit-3240 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000; STM32F411xE; MXCHIP; FreeRTOS_VERSION="7.1.0"
  ICCARM.CCIncludePath2: ..\..\..\..\demos\application\wifi_uart; ..\..\..\..\include; ..\..\..\..\board\MK3240; ..\..\..\..\platform\include; ..\..\..\..\platform\Cortex-M4; ..\..\..\..\platform\Cortex-M4\CMSIS; ..\..\..\..\platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\drivers\spi_flash; ..\..\..\..\libraries\drivers; ..\..\..\..\mico\system; ..\..\..\..\libraries\utilities\json_c; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\utilities\base64; ..\..\..\..\libraries\daemons\http_server; ..\..\..\..\mico\security; ..\..\..\..\libraries\daemons\homekit_server; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\include; ..\..\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS; ..\..\..\..\platform\MCU\STM32F4xx; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include; ..\..\..\..\MiCO\net\LwIP\ver1.4.0.rc1\src\include\ipv4; ..\..\..\..\platform
  AARM.AUserIncludes: ..\..\..\..\MiCO\RTOS\FreeRTOS\ver7.1.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico\Cortex-M3; ..\..\..\..\MiCO\RTOS\FreeRTOS\mico; ..\..\..\..\board\MK3165
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  group Application/AppFramework
    ../../../../demos/EP600_S/AppFramework/: MICOAppDefine.h MICOAppEntrance.c
  group Application/User
    ../../../../demos/EP600_S/User/: user_charge.c user_config.h user_device_check.c user_device_control.c user_downstream.c user_main.c user_modbus.c user_properties.c user_uart.c user_upstream.c
  group Board/MiCOKit-3165
    ../../../../board/MK3165/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3166
    ../../../../board/MK3166/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3238
    ../../../../board/MK3238/: platform.c platform.h platform_config.h wifi_nvram.c wifi_nvram_image.h
  group Board/MiCOKit-3239
    ../../../../board/MK3239/: platform.c platform.h platform_config.h wifi_nvram.c wifi_nvram_image.h
  group Board/MiCOKit-3240
    ../../../../board/MK3240/: platform.c platform.h platform_config.h wifi_nvram.c wifi_nvram_image.h
  group Board/MiCOKit-3288
    ../../../../board/MK3288/: platform.c platform.h platform_config.h
  group Board/NUCLEO_F411RE
    ../../../../board/NUCLEO_F411RE/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: common.h debug.h mico.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group libraries/bluetooth
    ../../../../libraries/bluetooth/dual_mode/: BTE_dual_mode.Cortex-M4.IAR.release.a
    ../../../../libraries/bluetooth/low_energy/: BTE_low_energy.Cortex-M4.IAR.release.a
  group libraries/bluetooth/BTE/Components/gki
    ../../../../libraries/bluetooth/BTE/Components/gki/common/: gki_buffer.c gki_debug.c gki_time.c
    ../../../../libraries/bluetooth/BTE/Components/gki/mico/: gki_mico.c
  group libraries/bluetooth/BTE/Components/hcis
    ../../../../libraries/bluetooth/BTE/Components/hcis/: hcill_proto.c hcilp.c hcisu_h4.c hciutil.c
  group libraries/bluetooth/BTE/Components/stack/brcm
    ../../../../libraries/bluetooth/BTE/Components/stack/brcm/: brcm_ble.c brcm_prm.c brcm_tbfc.c bte_brcm.c
  group libraries/bluetooth/BTE/Components/stack/btm
    ../../../../libraries/bluetooth/BTE/Components/stack/btm/: btm_acl.c btm_ble.c btm_ble_addr.c btm_ble_bgconn.c btm_ble_gap.c btm_ble_privacy.c btm_cfg.c btm_dev.c btm_devctl.c btm_inq.c btm_main.c btm_pm.c btm_sco.c btm_sec.c btm_sec_nvram.c
  group libraries/bluetooth/BTE/Components/stack/btu
    ../../../../libraries/bluetooth/BTE/Components/stack/btu/: btu_hcif.c btu_init.c btu_task.c
  group libraries/bluetooth/BTE/Components/stack/gap
    ../../../../libraries/bluetooth/BTE/Components/stack/gap/: gap_api.c gap_ble.c gap_conn.c gap_utils.c
  group libraries/bluetooth/BTE/Components/stack/gatt
    ../../../../libraries/bluetooth/BTE/Components/stack/gatt/: att_protocol.c gatt_api.c gatt_attr.c gatt_auth.c gatt_cl.c gatt_main.c gatt_sr.c gatt_utils.c
    ../../../../libraries/bluetooth/BTE/Components/stack/gatt/legattdb/: legattdb.c
  group libraries/bluetooth/BTE/Components/stack/hcic
    ../../../../libraries/bluetooth/BTE/Components/stack/hcic/: hciblecmds.c hcicmds.c
  group libraries/bluetooth/BTE/Components/stack/l2cap
    ../../../../libraries/bluetooth/BTE/Components/stack/l2cap/: l2c_api.c l2c_ble.c l2c_ble_conn.c l2c_ble_utils.c l2c_csm.c l2c_fcr.c l2c_link.c l2c_main.c l2c_utils.c
  group libraries/bluetooth/BTE/Components/stack/rfcomm
    ../../../../libraries/bluetooth/BTE/Components/stack/rfcomm/: port_api.c port_rfc.c port_utils.c rfc_l2cap_if.c rfc_mx_fsm.c rfc_port_fsm.c rfc_port_if.c rfc_ts_frames.c rfc_utils.c
  group libraries/bluetooth/BTE/Components/stack/sdp
    ../../../../libraries/bluetooth/BTE/Components/stack/sdp/: sdp_api.c sdp_db.c sdp_discovery.c sdp_main.c sdp_server.c sdp_utils.c
  group libraries/bluetooth/BTE/Components/stack/smp
    ../../../../libraries/bluetooth/BTE/Components/stack/smp/: aes.c p_256_curvepara.c p_256_ecc_pp.c p_256_multprecision.c smp_act.c smp_api.c smp_br_main.c smp_cmac.c smp_keys.c smp_l2c.c smp_main.c smp_utils.c
  group libraries/bluetooth/BTE/Components/stack/wbt
    ../../../../libraries/bluetooth/BTE/Components/stack/wbt/: wbt_ext.c
  group libraries/bluetooth/BTE/Components/udrv
    ../../../../libraries/bluetooth/BTE/Components/udrv/mico/: userial_mico.c
  group libraries/bluetooth/BTE/gki
    ../../../../libraries/bluetooth/BTE/Components/gki/common/: gki.h gki_common.h
  group libraries/bluetooth/BTE/mico_bt_api
    ../../../../libraries/bluetooth/BTE/mico_bt_api/: mico_bt_ble_wrapper.c mico_bt_dev_wrapper.c mico_bt_gatt.c mico_bt_gatt_wrapper.c mico_bt_hidd_ble_wrapper.c mico_bt_int.h mico_bt_l2c_le_wrapper.c mico_bt_l2c_wrapper.c mico_bt_main.c mico_bt_rfcomm_wrapper.c mico_bt_sco_wrapper.c mico_bt_sdp.c mico_bt_sdp_wrapper.c
  group libraries/bluetooth/BTE/Projects
    ../../../../libraries/bluetooth/BTE/Projects/bte/main/: bte_hcisu.c bte_init.c bte_load.c bte_version.c
    ../../../../libraries/bluetooth/BTE/Projects/bte/embedded/mico/lib/: mico_post_reset.c
  group libraries/bluetooth/BTE/proto_disp
    ../../../../libraries/bluetooth/BTE/proto_disp/: hcidisp.c
  group libraries/bluetooth/firmware/43438A1
    ../../../../libraries/bluetooth/firmware/43438A1/26MHz/: bt_firmware_image.c
  group libraries/bluetooth/mico_bt_platform
    ../../../../libraries/bluetooth/BTE/mico_bt_platform/: mico_bt_bus.c mico_bt_hcd.c mico_bt_logmsg.c mico_bt_nvram_access.c mico_upio.c
  group libraries/daemons/bt_smart
    ../../../../libraries/daemons/bt_smart/: mico_bt_management.c mico_bt_peripheral.c mico_bt_smartbridge.c mico_bt_smartbridge_cfg.c mico_bt_smartbridge_cfg_size.c mico_bt_smartbridge_gatt.c
  group libraries/daemons/bt_smart/include
    ../../../../libraries/daemons/bt_smart/include/: mico_bt.h mico_bt_peripheral.h mico_bt_smart_attribute.h mico_bt_smart_interface.h mico_bt_smartbridge.h mico_bt_smartbridge_constants.h mico_bt_smartbridge_gatt.h
  group libraries/daemons/bt_smart/internal
    ../../../../libraries/daemons/bt_smart/internal/: bt_peripheral_stack_interface.c bt_peripheral_stack_interface.h bt_smart_attribute.c bt_smartbridge_att_cache_manager.c bt_smartbridge_att_cache_manager.h bt_smartbridge_helper.c bt_smartbridge_helper.h bt_smartbridge_socket_manager.c bt_smartbridge_socket_manager.h bt_smartbridge_stack_interface.c bt_smartbridge_stack_interface.h
  group libraries/daemons/homekit_server
    ../../../../libraries/daemons/homekit_server/: Lib_HomeKit_Server.Cortex-M4F.IAR.release.a
  group libraries/daemons/http_server
    ../../../../libraries/daemons/http_server/: http-strings.c http-strings.h http_parse.c http_parse.h httpd.c httpd.h httpd_handle.c httpd_priv.h httpd_ssi.c httpd_sys.c httpd_wsgi.c
  group libraries/Drivers/display/VGM128064
    ../../../../libraries/drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group libraries/Drivers/keypad/gpio_button
    ../../../../libraries/drivers/keypad/gpio_button/: button.c button.h
  group libraries/Drivers/led/P9813
    ../../../../libraries/drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group libraries/Drivers/MFiAuth
    ../../../../libraries/drivers/MiCODriverMFiAuth/: MiCODriverMFiAuth.a
  group libraries/Drivers/MiCOKit-EXT
    ../../../../libraries/drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c motion_sensor.c motion_sensor.h temp_hum_sensor.c
  group libraries/Drivers/MiCOKit-STmem
    ../../../../libraries/drivers/MiCOKit_STmems/: MiCOKit_STmems.c MiCOKit_STmems.h MiCOKit_STmems_def.h
  group libraries/Drivers/motor/dc_motor
    ../../../../libraries/drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group libraries/Drivers/sensor/ADPS9930
    ../../../../libraries/drivers/sensor/APDS9930/: APDS9930.c APDS9930.h
  group libraries/Drivers/sensor/BMA2x2
    ../../../../libraries/drivers/sensor/BMA2x2/: bma2x2.c bma2x2.h bma2x2_user.c bma2x2_user.h
  group libraries/Drivers/sensor/BME280
    ../../../../libraries/drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group libraries/Drivers/sensor/BMG160
    ../../../../libraries/drivers/sensor/BMG160/: bmg160.c bmg160.h bmg160_user.c bmg160_user.h
  group libraries/Drivers/sensor/BMM050
    ../../../../libraries/drivers/sensor/BMM050/: bmm050.c bmm050.h bmm050_user.c bmm050_user.h
  group libraries/Drivers/sensor/DHT11
    ../../../../libraries/drivers/sensor/DHT11/: DHT11.c DHT11.h
  group libraries/Drivers/sensor/HTS221
    ../../../../libraries/drivers/sensor/HTS221/: hts221.c hts221.h
  group libraries/Drivers/sensor/infrared_adc
    ../../../../libraries/drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group libraries/Drivers/sensor/light_adc
    ../../../../libraries/drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group libraries/Drivers/sensor/LPS25HB
    ../../../../libraries/drivers/sensor/LPS25HB/: lps25hb.c lps25hb.h
  group libraries/Drivers/sensor/LSM9DS1
    ../../../../libraries/drivers/sensor/LSM9DS1/: lsm9ds1.h lsm9ds1_acc_gyr.c lsm9ds1_mag.c
  group libraries/Drivers/sensor/UVIS25
    ../../../../libraries/drivers/sensor/UVIS25/: uvis25.c uvis25.h
  group libraries/Drivers/SPI Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group libraries/protocols
    ../../../../libraries/protocols/fog_v2/fog_ota/: fog2_ota_notification.c fog_ota.c url.c
    ../../../../libraries/protocols/fog_v2/fog_bonjour/: fog_bonjour.c
    ../../../../libraries/protocols/fog_v2/fog_http/: fog_http_client.c fog_v2.c fog_v2_sub.c fog_v2_sub_device_management.c fog_v2_user_notification.c
    ../../../../libraries/protocols/fog_v2/fog_mqtt/: fog_mqtt.c fog_process_mqtt_cmd.c
    ../../../../libraries/protocols/fog_v2/fog_tcp_server/: fog_tcp_server.c
    ../../../../libraries/protocols/fog_v2/: fog_v2_config.h
    ../../../../libraries/protocols/mqtt/: MQTTClient.c
    ../../../../libraries/protocols/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../../../libraries/protocols/mqtt/mico/: MQTTMiCO.c
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c LinkListUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/base64
    ../../../../libraries/utilities/base64/: base64.c base64.h
  group libraries/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.h json.h json_debug.c json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group mico/core
    ../../../../MiCO/core/: MiCO.1062.SDIO.Cortex-M4.IAR.a MiCO.1062.SPI.Cortex-M4.IAR.a MiCO.1088.SDIO.Cortex-M4.IAR.a MiCO.3166.IAR.a MiCO.3238.IAR.a MiCO.3239.IAR.a mico_config.c
    ../../../../MiCO/core/rf_driver/: wlan_firmware.c
  group mico/net/LwIP/mico
    ../../../../MiCO/net/LwIP/mico/: mico_socket.c
  group mico/RTOS
    ../../../../MiCO/RTOS/: mico_rtos_common.c
  group mico/RTOS/FreeRTOS/mico
    ../../../../MiCO/RTOS/FreeRTOS/mico/: mico_rtos.c
  group mico/RTOS/FreeRTOS/ver9.0.0
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/portable/MemMang/: heap_3.c
    ../../../../MiCO/RTOS/FreeRTOS/ver9.0.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group mico/security
    ../../../../MiCO/security/Sodium/: Lib_Sodium.IAR.release.a
    ../../../../MiCO/security/SRP_6a/: Lib_SRP6a.IAR.release.a
  group mico/security/curve25519
    ../../../../MiCO/security/Curve25519/: curve25519-donna.c
  group mico/security/SHA
    ../../../../MiCO/security/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group mico/security/TLS
    ../../../../MiCO/security/TLS/wolfSSL/: Lib_wolfSSL.Cortex-M4F.IAR.release.a
  group mico/system
    ../../../../MiCO/system/config_server/: config_server.c config_server_menu.c
    ../../../../MiCO/system/command_console/: mico_cli.c
    ../../../../MiCO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c mico_system_time.c system_misc.c
    ../../../../MiCO/system/tftp_ota/: tftp_ota.c tftpc.c
  group mico/system/easylink
    ../../../../MiCO/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../MiCO/system/easylink/MFi_WAC/: Lib_MFi_WAC.Cortex-M4F.IAR.release.a
    ../../../../MiCO/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss.a
    ../../../../MiCO/system/easylink/: system_easylink.c system_easylink_delegate.c system_easylink_wac.c
  group mico/system/mdns
    ../../../../MiCO/system/mdns/: mico_mdns.c mico_mdns.h system_discovery.c
  group mico/system/qc_test
    ../../../../MiCO/system/qc_test/: qc_test.c
    ../../../../MiCO/system/qc_test/internal/: qc_test_cli.c qc_test_gpio.c qc_test_tcpip.c
  group Platform
    ../../../../platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../platform/Cortex-M4/: crt0_EWARM.c hardfault.c platform_core.c
  group Platform/EWARM
    ../../../../platform/EWARM/: Retarget.c
  group Platform/STM32F4xx
    ../../../../platform/MCU/STM32F4xx/: platform_init.c
    ../../../../platform/MCU/: platform_nsclock.c
  group Platform/STM32F4xx/EWARM
    ../../../../platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_IAR.s startup_stm32f412xg_IAR.s
  group Platform/STM32F4xx/Peripherals
    ../../../../platform/MCU/STM32F4xx/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/STM32F4xx/Peripherals/Libraries
    ../../../../platform/MCU/STM32F4xx/peripherals/libraries/: system_stm32f4xx.c
  group Platform/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../platform/MCU/STM32F4xx/peripherals/libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/STM32F4xx/Wi-Fi_Bus_Driver
    ../../../../platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_SDIO.c wlan_bus_SPI.c wlan_platform.c
