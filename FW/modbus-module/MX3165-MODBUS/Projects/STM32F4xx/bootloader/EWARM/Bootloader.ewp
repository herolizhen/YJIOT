# IAR project Bootloader.ewp, settings and files
configuration MiCOKit-3165 (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; BOOTLOADER; NO_MICO_RTOS; HSE_VALUE=26000000; STM32F411xE
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MK3165; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\platform
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3165\bootloaderLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3288 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; BOOTLOADER; NO_MICO_RTOS; HSE_VALUE=16000000; STM32F411xE
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MK3288; ..\..\..\..\Platform; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3288\bootloaderLinkerForIAR.icf
configuration NUCLEO_F411RE (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\NUCLEO_F411RE; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\platform
  ILINK.IlinkIcfFile: ..\..\..\..\Board\NUCLEO_F411RE\bootloaderLinkerForIAR.icf
configuration EMW3238 (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MK3238; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\platform
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3238\bootloaderLinkerForIAR.icf
configuration MiCOKit-3166 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F412RG ST STM32F412RG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; BOOTLOADER; NO_MICO_RTOS; HSE_VALUE=26000000; STM32F412xG
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MK3166; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\platform
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3166\bootloaderLinkerForIAR.icf
configuration MiCOKit-3240 (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MK3240; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\platform
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MK3240\bootloaderLinkerForIAR.icf
configuration MiCOKit-3239 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F412RG ST STM32F412RG
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\board\MK3239; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\libraries\Drivers\spi_flash; ..\..\..\..\libraries\Drivers\MiCOKit_EXT; ..\..\..\..\libraries\utilities; ..\..\..\..\mico\system; ..\..\..\..\mico\security; ..\..\..\..\libraries\Drivers; ..\..\..\..\platform
  ILINK.IlinkIcfFile: as above
  group Board/EMW3240
    ../../../../board/MK3240/: platform.c platform.h platform_config.h wifi_nvram.c wifi_nvram_image.h
  group Board/MiCOKit-3165
    ../../../../board/MK3165/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3166
    ../../../../board/MK3166/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3238
    ../../../../board/MK3238/: platform.c platform.h platform_config.h wifi_nvram.c wifi_nvram_image.h
  group Board/MiCOKit-3239
    ../../../../board/MK3239/: platform.c platform.h platform_config.h wifi_nvram.c wifi_nvram_image.h
  group Board/MiCOKit-3288
    ../../../../board/MK3288/: platform.c platform.h platform_config.h
  group Board/NUCLEO_F411RE
    ../../../../board/NUCLEO_F411RE/: platform.c platform.h platform_config.h
  group Bootloader
    ../../../../bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
    ../../../../Bootloader/: mico_config.h MicoDefaults.h
  group include
    ../../../../include/: mico.h mico_platform.h mico_rtos.h mico_security.h mico_socket.h mico_system.h mico_wlan.h
  group include/MicoDriver
    ../../../../include/MiCODrivers/: MiCODriverAdc.h MiCODriverGpio.h MiCODriverI2c.h MiCODriverMFiAuth.h MiCODriverPwm.h MiCODriverRng.h MiCODriverRtc.h MiCODriverSpi.h MiCODriverUart.h MiCODriverWdg.h
  group libraries/Drivers/led/P9813
    ../../../../libraries/drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group libraries/Drivers/MiCOKit-EXT
    ../../../../libraries/drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c motion_sensor.c motion_sensor.h temp_hum_sensor.c
  group libraries/Drivers/MiCOKit-STmem
    ../../../../libraries/drivers/MiCOKit_STmems/: MiCOKit_STmems.c MiCOKit_STmems.h MiCOKit_STmems_def.h
  group libraries/Drivers/motor/dc_motor
    ../../../../libraries/drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group libraries/Drivers/SPI Flash
    ../../../../libraries/drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group libraries/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c RingBufferUtils.c StringUtils.c
  group mico/RTOS/NoRTOS
    ../../../../MiCO/RTOS/NoRTOS/: rtos.c
  group Platform/Cortex-M4
    ../../../../platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/EWARM
    ../../../../platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../platform/MCU/: mico_platform_common.c platform_nsclock.c wlan_platform_common.c
  group Platform/MCU/STM32F4xx
    ../../../../platform/MCU/STM32F4xx/: platform_init.c
  group Platform/MCU/STM32F4xx/EWARM
    ../../../../platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_bootloader_IAR.s startup_stm32f412xg_bootloader_IAR.s
  group Platform/MCU/STM32F4xx/Peripherals/Libraries
    ../../../../platform/MCU/STM32F4xx/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
    ../../../../platform/MCU/STM32F4xx/peripherals/libraries/: system_stm32f4xx.c
  group Platform/MCU/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../platform/MCU/STM32F4xx/peripherals/libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/MCU/STM32F4xx/wifi_wlan_bus
    ../../../../platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_SPI.c wlan_platform.c
