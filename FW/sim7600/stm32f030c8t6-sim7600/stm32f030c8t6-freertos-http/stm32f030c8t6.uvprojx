# Keil uVision project stm32f030c8t6.uvprojx, settings and files
target stm32f030c8t6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f030c8t6
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\Library\STM32F0xx_StdPeriph_Driver\inc;.\Library\CMSIS;.\User;.\Library\STM32F0xx_StdPeriph_Driver\src;.\Library\CMSIS\Include;.\Library\CMSIS\Device\ST\STM32F0xx\Include;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM0;.\json;.\User\user_flash;.\User\user_sim7600;.\User\user_usart;.\User\charge
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f030.s
  group library
    ./Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_pwr.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_wwdg.c
  group user
    ./User/: main.c system_stm32f0xx.c stm32f0xx_it.c
    ./User/user_flash/: user_flash.c
    ./User/user_sim7600/: user_sim7600.c sim7600.c
    ./User/user_usart/: usart2.c usart.c usart1.c
    ./User/charge/: charge.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_2.c
    ./FreeRTOS/portable/RVDS/ARM_CM0/: port.c
  group json
    ./json/: cJSON.c
  group output
    ./Listings/: stm32f030c8t6.map
