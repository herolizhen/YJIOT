# Keil uVision project stm32f103-ucosii.uvprojx, settings and files
target stm32f103c8t6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F101C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103-ucosii
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\CMSIS;.\FWlib\inc;.\uCOS-II\Ports;.\uCOS-II\Source;.\malloc;.\modbus;.\APP;.\BSP;.\user;.\json;.\user\flash;.\user\user_usart;.\user\charge;.\user\user_sim7600
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group user
    ./user/: main.c stm32f10x_it.c
    ./user/flash/: user_flash.c
    ./user/user_config/: user_config.c
    ./user/user_usart/: user_usart.c user_usart1.c user_usart2.c user_usart3.c
    ./user/user_modbus/: user_modbus.c
    ./user/charge/: charge.c
    ./user/user_sim7600/: sim7600.c user_sim7600.c user_mqtt_task.c user_sim7600_task.c user_upload_data.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group bsp
    ./BSP/: BSP.c led.c
  group app
    ./APP/: app.c
  group uCOS-II\Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ./uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group malloc
    ./malloc/: malloc.c
  group modbus
    ./modbus/: modbus_master.c ringbuffer.c trans_recieve_buff_control.c
  group json
    ./json/: cJSON.c
  group list
    ./Listings/: stm32f103-ucosii.map
